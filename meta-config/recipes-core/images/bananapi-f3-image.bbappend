# meta-custom/recipes-core/images/core-image-minimal.bbappend

IMAGE_INSTALL:append = " gcc libgcc make libc-dev glibc-dev kernel-dev"
